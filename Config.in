## Config.in
```kconfig
config BR2_PACKAGE_SERVER
    bool "server"
    help
        myserver package.

        serverrrrrrrrr
```
